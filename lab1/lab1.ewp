# IAR project lab1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: STM32L1xx_StdPeriph_Driver\inc; STM32L1xx_StdPeriph_Driver\src; CMSIS\CM3\DeviceSupport\ST\STM32L1xx; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Users\Akela\Desktop\lab1\lab1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c stm32l1xx_conf.h
  group StdPeriph/inc
    STM32L1xx_StdPeriph_Driver/inc/: stm32l1xx_gpio.h stm32l1xx_rcc.h
  group StdPeriph/src
    STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_gpio.c stm32l1xx_rcc.c
