# IAR project lab2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: CMSIS\DeviceSupport\ST\STM32L1xx; ; STM32L1xx_StdPeriph_Driver\inc; STM32L1xx_StdPeriph_Driver\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lab2.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: lab2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: discover_board.h main.c stm32l1xx_conf.h stm32l_discovery_lcd.c stm32l_discovery_lcd.h
    CMSIS/DeviceSupport/ST/STM32L1xx/: stm32l1xx.h
  group SPL/inc
    STM32L1xx_StdPeriph_Driver/inc/: stm32l1xx_gpio.h stm32l1xx_lcd.h stm32l1xx_rcc.h
  group SPL/src
    STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_gpio.c stm32l1xx_lcd.c stm32l1xx_rcc.c
