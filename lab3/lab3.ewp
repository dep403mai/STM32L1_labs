# IAR project lab3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: STM32L1xx_StdPeriph_Driver\inc; STM32L1xx_StdPeriph_Driver\src; CMSIS\CM3\DeviceSupport\ST\STM32L1xx; STM32_TouchSensing_Driver\src; STM32_TouchSensing_Driver\inc; Discovery; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Users\Akela\Desktop\lab3\lab3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
    CMSIS/CM3/DeviceSupport/ST/STM32L1xx/: stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h
  group Config
    ./: stm32_tsl_conf.h stm32l1xx_conf.h
  group Discovery_functions
    Discovery/: discover_functions.c discover_functions.h
  group Discovery_LCD
    Discovery/: discover_board.h stm32l_discovery_lcd.c stm32l_discovery_lcd.h
  group SPL/inc
    STM32L1xx_StdPeriph_Driver/inc/: stm32l1xx_exti.h stm32l1xx_gpio.h stm32l1xx_lcd.h stm32l1xx_rcc.h
  group SPL/src
    STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_lcd.c stm32l1xx_rcc.c
  group TSL/inc
    STM32_TouchSensing_Driver/inc/: stm32_tsl_api.h stm32_tsl_checkconfig.h stm32_tsl_conf_TOADAPT.h stm32_tsl_internal.h stm32_tsl_multichannelkey.h stm32_tsl_services.h stm32_tsl_singlechannelkey.h stm32_tsl_timebase.h stm32l15x_tsl_ct_acquisition.h
  group TSL/src
    STM32_TouchSensing_Driver/src/: stm32_tsl_api.c stm32_tsl_multichannelkey.c stm32_tsl_services.c stm32_tsl_singlechannelkey.c stm32_tsl_timebase.c stm32l15x_tsl_ct_acquisition.c
